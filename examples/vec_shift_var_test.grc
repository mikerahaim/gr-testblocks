<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vec_shift_var_test</value></param>
<param><key>author</key><value>Michael Rahaim</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test the variable length vector shift block</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shift</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_len</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vec_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>range(0,vec_len)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vec_len</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>testblocks_vec_shift_var</key>
<param><key>id</key><value>testblocks_vec_shift_var_0</value></param>
<param><key>shift</key><value>shift</value></param>
<param><key>vec_len</key><value>vec_len</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>testblocks_vec_shift_var_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>testblocks_vec_shift_var_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
